Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-31T13:33:49+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Interface utilisateur alternative 23.0.11.19

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 807373; RefLongitude: 2, 21, 7, 999076; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 0
LongName: Niveau 0; Elevation: 0 mm

# IfcBuildingElementProxy: Pump-Inline_Circulator-Grundfos_ALPHA2-BIMEPAUS REVISION 3:PLEASE USE TYPE CATALOG, Pump-Inline_Circulator-Grundfos_ALPHA2-BIMEPAUS REVISION 3:PLEASE USE TYPE CATALOG:741487
In: Niveau 0
Type - Material: Grundfos - Red (7), Grundfos - Light Black (4), Grundfos - Insulation
Type - Pset_ManufacturerTypeInformation - Manufacturer: Grundfos
Pset_BuildingElementProxyCommon - Reference: PLEASE USE TYPE CATALOG; sets with these values: 2

# IfcDistributionPort (59)
Description: Flow
Name | FlowDirection | Group
2 x Port_741439 | SOURCEANDSINK | CUI-A 1
InPort_741440 | SOURCEANDSINK | CUI-A 2
2 x OutPort_741490 | SOURCEANDSINK | CUI-A 2
Port_741440 | SOURCEANDSINK | CUI-A 2
InPort_741442 | SOURCEANDSINK | CUI-A 3
OutPort_741473 | SOURCEANDSINK | CUI-A 3
Port_741443 | SOURCEANDSINK | CUI-A 4
2 x InPort_741443 | SOURCEANDSINK | CUI-A 4
OutPort_741454 | SOURCEANDSINK | CUI-A 4
OutPort_741494 | SOURCEANDSINK | CUI-A 4
2 x Port_741445 | SOURCEANDSINK | CUI-A 5
Port_741454 | SOURCEANDSINK | CUI-A 4
InPort_741456 | SOURCEANDSINK | CUI-A 7
OutPort_741471 | SOURCEANDSINK | CUI-A 7
Port_741456 | SOURCEANDSINK | CUI-A 7
Port_741457 | SOURCEANDSINK | CUI-A 8
InPort_741457 | SOURCEANDSINK | CUI-A 8
OutPort_741465 | SOURCEANDSINK | CUI-A 8
InPort_741459 | SOURCEANDSINK | CUI-A 9
OutPort_741463 | SOURCEANDSINK | CUI-A 9
Port_741459 | SOURCEANDSINK | CUI-A 9
2 x InPort_741461 | SOURCEANDSINK | CD-A 1
2 x OutPort_741469 | SOURCEANDSINK | CD-A 1
OutPort_741475 | SOURCEANDSINK | CD-A 1
InPort_741463 | SOURCEANDSINK | CD-A 1
2 x OutPort_741476 | SOURCEANDSINK | CD-A 1
Port_741465 | SOURCEANDSINK | CUI-A 8
2 x InPort_741467 | SOURCEANDSINK | CD-A 1
OutPort_741471 | SOURCEANDSINK | CD-A 1
InPort_741473 | SOURCEANDSINK | CUI-A 3
OutPort_741481 | SOURCEANDSINK | CUI-A 3
2 x InPort_741475 | SOURCEANDSINK | CD-A 1
OutPort_741479 | SOURCEANDSINK | CD-A 1
InPort_741479 | SOURCEANDSINK | CD-A 1
OutPort_741483 | SOURCEANDSINK | CD-A 1
InPort_741481 | SOURCEANDSINK | CUI-A 3
OutPort_741483 | SOURCEANDSINK | CUI-A 3
2 x Port_741485 | SOURCEANDSINK | CUI-A 12
2 x Port_741486 | SOURCEANDSINK | CUI-A 13
Port_741487 | SINK
Port_741487 | SOURCE
Port_741487 | SOURCEANDSINK
Port_741488 | SOURCEANDSINK | CUI-A 2
2 x InPort_741488 | SOURCEANDSINK | CUI-A 2
OutPort_741492 | SOURCEANDSINK | CUI-A 2
Port_741492 | SOURCEANDSINK | CUI-A 2
Port_741494 | SOURCEANDSINK | CUI-A 4

# IfcFlowController: Manometre pose verticale:Cadran 63 mm DN12, Manometre pose verticale:Cadran 63 mm DN12:741442
In: Niveau 0
Type - Material: Generic copy(1)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Citec
Material: Generic copy(1), <Unnamed>; Group: CUI-A 3
Pset_DistributionFlowElementCommon - Reference: Cadran 63 mm DN12; sets with these values: 2

# IfcFlowController: Robinet Boisseau Sphérique avec Raccord Union:Fisa (2)
In: Niveau 0
Type - Material: <Unnamed> (6), Corps Laiton (3), Poignée Rouge
Pset_DistributionFlowElementCommon - Reference: Fisa; sets with these values: 2
Name (Robinet Boisseau Sphérique avec Raccord Union:Fisa:...) | Group
741485 | CUI-A 12
741486 | CUI-A 13 | Material: <Unnamed>, Corps Laiton, Poignée Rouge

# IfcFlowController: Robinet Boisseau Sphérique:Standard (2)
In: Niveau 0
Type - Material: Corps Laiton (3), Poignée Rouge
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Robinet Boisseau Sphérique:Standard:...) | Group
741439 | CUI-A 1
741456 | CUI-A 7 | Material: Corps Laiton, Poignée Rouge

# IfcFlowFitting: Coude Cuivre SUDO:Standard, Coude Cuivre SUDO:Standard:741469
In: Niveau 0
Type - Material: Cuivre Sanitaire (4)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: CD-A 1

# IfcFlowFitting: Coude Cuivre cintré:Standard (2)
In: Niveau 0
Type - Material: Cuivre Sanitaire (2)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Coude Cuivre cintré:Standard:...) | Group
741463 | CUI-A 9; CD-A 1
741483 | CUI-A 3; CD-A 1 | Material: Cuivre Sanitaire

# IfcFlowFitting: Piquage Acier Noir droit:Longueur = 25 (2)
In: Niveau 0
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Longueur = 25; sets with these values: 2
Name (Piquage Acier Noir droit:Longueur = 25:...) | Group
741454 | CUI-A 4
741490 | CUI-A 2

# IfcFlowFitting: Raccord Union Fileté Mâle-Mâle:Standard (2)
In: Niveau 0
Type - Material: <Unnamed> (7)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (Raccord Union Fileté Mâle-Mâle:Standard:...) | Group
741492 | CUI-A 2
741494 | CUI-A 4 | Material: <Unnamed>

# IfcFlowFitting: Réduction Acier:Longueur = x3, Réduction Acier:Longueur = x3:741465
In: Niveau 0
Type - Material: Acier T3
Pset_DistributionFlowElementCommon - Reference: Longueur = x3; sets with these values: 2
Group: CUI-A 8

# IfcFlowFitting: Réduction Cuivre SUDO:Standard, Réduction Cuivre SUDO:Standard:741471
In: Niveau 0
Type - Material: Cuivre Sanitaire (3)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: CUI-A 7; CD-A 1

# IfcFlowFitting: Réduction Cuivre:Standard, Réduction Cuivre:Standard:741473
In: Niveau 0
Type - Material: Cuivre Sanitaire
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: CUI-A 3

# IfcFlowFitting: Té Cuivre SUDO droit:Standard, Té Cuivre SUDO droit:Standard:741475
In: Niveau 0
Type - Material: Cuivre Sanitaire (4)
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Group: CD-A 1

# IfcFlowSegment: Canalisation:Acier T10 par piquage avec coude 3D (5)
In: Niveau 0
Pset_DistributionFlowElementCommon - Reference: Acier T10 par piquage avec coude 3D; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Canalisation:Acier T10 par piquage avec coude 3D:...) | Length (mm) | Group
741440 | 80.4113 | CUI-A 2
741443 | 453.44 | CUI-A 4
741445 | 28.4407 | CUI-A 5
741457 | 49.9113 | CUI-A 8
741488 | 520 | CUI-A 2

# IfcFlowSegment: Canalisation:Cuivre avec coude SUDO (3)
In: Niveau 0
Pset_DistributionFlowElementCommon - Reference: Cuivre avec coude SUDO; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Group: CD-A 1
Name (Canalisation:Cuivre avec coude SUDO:...) | Length (mm)
741461 | 225.805
741467 | 60.4475
741476 | 197.072

# IfcFlowSegment: Canalisation:Cuivre avec coude cintré main (3)
In: Niveau 0
Pset_DistributionFlowElementCommon - Reference: Cuivre avec coude cintré main; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Canalisation:Cuivre avec coude cintré main:...) | Length (mm) | Group
741459 | 79.8 | CUI-A 9
741479 | 90.6475 | CD-A 1
741481 | 82.8707 | CUI-A 3
